# Keil uVision project Motor_Control_GD32_FreeRTOS.uvprojx, settings and files
target Motor_Control_GD32_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Motor_Control_GD32_FreeRTOS +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1,__TARGET_FPU_VFP
  c include: ..\User;..\Libraries\CMSIS\GD\GD32F30x\Include;..\Libraries\CMSIS;..\Libraries\GD32F30x_standard_peripheral\Include;..\LCD;..\FOC;..\User\BSP;..\User\Task;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: gd32f30x_it.c main.c motor_hardware.c motor_config.h FreeRTOSConfig.h
  group BSP
    ../User/BSP/: adc_simple.c can.c delay.c eeprom.c i2c.c led.c ntc.c spi.c systick.c uart.c drv8323rs.c encoder.c
  group Task
    ../User/Task/: motor_app.c
  group CMSIS
    ../Libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../Libraries/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ../Libraries/CMSIS/: arm_cortexM4lf_math.lib arm_math.h
  group Periph_Driver
    ../Libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group LCD
    ../LCD/: lcd.c lcd_init.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FOC
    ../FOC/: foc.c pmsm.c pll_estimator.c userparms.h
