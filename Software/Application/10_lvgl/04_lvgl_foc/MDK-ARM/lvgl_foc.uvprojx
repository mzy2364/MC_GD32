# Keil uVision project lvgl_foc.uvprojx, settings and files
target lvgl_foc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lvgl_foc +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,LV_CONF_INCLUDE_SIMPLE,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1,__TARGET_FPU_VFP
  c include: ..\User;..\Libraries\CMSIS\GD\GD32F30x\Include;..\Libraries\CMSIS;..\Libraries\GD32F30x_standard_peripheral\Include;..\LCD;..\lvgl;..\lvgl\porting;..\lvgl\src;..\lv_demo\lv_apps\demo;..\lv_demo\lv_apps\benchmark;..\User\BSP;..\User\Task;..\FOC;..\lvgl_app
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: gd32f30x_it.c main.c motor_hardware.c ee_parameter.c
    ../lvgl/: lv_conf.h
  group Bsp
    ../User/BSP/: adc_simple.c can.c delay.c drv8323rs.c eeprom.c encoder.c i2c.c led.c ntc.c spi.c systick.c uart.c
  group Task
    ../User/Task/: motor_app.c task.c
  group CMSIS
    ../Libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../Libraries/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ../Libraries/CMSIS/: arm_cortexM4lf_math.lib arm_math.h
  group Periph_Driver
    ../Libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group LCD
    ../LCD/: lcd.c lcd_init.c
  group lvgl
    ../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lvgl_port
    ../lvgl/porting/: lv_port_disp_mcgd32.c
  group lvgl_app
    ../lvgl_app/: mainwindow.c ui_monitor.c ui_set.c gbk_puhui16.c rotor.c
  group FOC
    ../FOC/: foc.c pll_estimator.c pmsm.c userparms.h
