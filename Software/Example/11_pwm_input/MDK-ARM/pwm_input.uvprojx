# Keil uVision project pwm_input.uvprojx, settings and files
target pwm_input (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pwm_input +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\User;..\Libraries\CMSIS\GD\GD32F30x\Include;..\Libraries\CMSIS;..\Libraries\GD32F30x_standard_peripheral\Include;..\LCD
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: gd32f30x_it.c main.c systick.c pwm_input.c led.c uart.c motor_hardware.c spi.c motor_config.h
  group CMSIS
    ../Libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../Libraries/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Periph_Driver
    ../Libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
